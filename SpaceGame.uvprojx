# Keil uVision project SpaceGame.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKL46Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Exercise12
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: MKL46Z4.s SpaceGame.c SpaceGame.h SpaceGame.s UART0CharIO.s UART0CharIO.h SGRender.h TouchDriver.s TouchDriver.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
